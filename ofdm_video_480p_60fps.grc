options:
  parameters:
    category: Custom
    description: OFDM Video Transmission - 480p @ 60fps
    generate_options: qt_gui
    id: ofdm_video_480p_60fps
    output_language: python
    title: OFDM Video 480p 60fps
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Packets
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: (list(range(-100, -53)) + list(range(-52, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 53)) + list(range(54, 101)),)
    packet_len_key: len_tag_key
    payload_mod: '"64QAM"'
    pilot_carriers: ((-53, -21, -7, 7, 21, 53),)
    pilot_symbols: ((1, 1, 1, -1, -1, 1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: (list(range(-100, -53)) + list(range(-52, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 53)) + list(range(54, 101)),)
    packet_len_key: len_tag_key
    payload_mod: '"64QAM"'
    pilot_carriers: ((-53, -21, -7, 7, 21, 53),)
    pilot_symbols: ((1, 1, 1, -1, -1, 1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import cv2
      from gnuradio import gr
      import threading
      import queue
      import time

      class LiveVideoTransmitter(gr.sync_block):
          """
          High-performance webcam video transmitter for 480p @ 60fps
          Produces continuous stream of grayscale camera bytes
          """
          def __init__(self, camera_index=0, frame_width=640, frame_height=480, fps_target=60):
              gr.sync_block.__init__(
                  self,
                  name="LiveVideoTransmitter_480p60",
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              
              # Parameters
              self.camera_index = int(camera_index)
              self.frame_width = int(frame_width)
              self.frame_height = int(frame_height)
              self.fps_target = float(fps_target)
              
              # Thread-safe frame queue
              self.frame_queue = queue.Queue(maxsize=10)
              self.capture_thread = None
              self.running = False
              self.current_frame = None
              self.frame_pos = 0
              
          def _capture_loop(self):
              """Background thread for camera capture"""
              cap = cv2.VideoCapture(self.camera_index)
              if not cap.isOpened():
                  print(f"ERROR: Cannot open camera {self.camera_index}")
                  return
                  
              # Configure camera for best performance
              cap.set(cv2.CAP_PROP_FRAME_WIDTH, self.frame_width)
              cap.set(cv2.CAP_PROP_FRAME_HEIGHT, self.frame_height)
              cap.set(cv2.CAP_PROP_FPS, self.fps_target)
              cap.set(cv2.CAP_PROP_BUFFERSIZE, 1)  # Minimize buffer lag
              
              # Use MJPEG if available for higher fps
              cap.set(cv2.CAP_PROP_FOURCC, cv2.VideoWriter_fourcc('M','J','P','G'))
              
              frame_interval = 1.0 / self.fps_target
              next_frame_time = time.time()
              
              while self.running:
                  ret, frame = cap.read()
                  if not ret or frame is None:
                      time.sleep(0.001)
                      continue
                      
                  # Convert to grayscale
                  gray = cv2.cvtColor(frame, cv2.COLOR_BGR2GRAY)
                  
                  # Resize if needed
                  if gray.shape[1] != self.frame_width or gray.shape[0] != self.frame_height:
                      gray = cv2.resize(gray, (self.frame_width, self.frame_height), 
                                            interpolation=cv2.INTER_LINEAR)
                  
                  # Convert to contiguous array
                  frame_bytes = np.ascontiguousarray(gray.ravel().astype(np.uint8))
                  
                  # Add to queue (non-blocking)
                  try:
                      self.frame_queue.put(frame_bytes, block=False)
                  except queue.Full:
                      # Drop frame if queue is full
                      pass
                  
                  # Frame rate control
                  next_frame_time += frame_interval
                  sleep_time = next_frame_time - time.time()
                  if sleep_time > 0:
                      time.sleep(sleep_time)
                  else:
                      next_frame_time = time.time()
              
              cap.release()
              
          def start(self):
              """Start camera capture thread"""
              self.running = True
              self.capture_thread = threading.Thread(target=self._capture_loop, daemon=True)
              self.capture_thread.start()
              return super().start()
              
          def work(self, input_items, output_items):
              """Produce output samples"""
              out = output_items[0]
              n = len(out)
              
              if n == 0:
                  return 0
                  
              # Get new frame from queue if available
              while not self.frame_queue.empty():
                  try:
                      self.current_frame = self.frame_queue.get_nowait()
                      self.frame_pos = 0
                  except queue.Empty:
                      break
              
              # If no frame available, output zeros
              if self.current_frame is None:
                  out[:] = 0
                  return n
                  
              frame_len = len(self.current_frame)
              pos = 0
              
              # Fill output buffer
              while pos < n:
                  remaining_in_frame = frame_len - self.frame_pos
                  remaining_in_output = n - pos
                  
                  if remaining_in_frame <= 0:
                      # Frame exhausted, repeat from beginning
                      self.frame_pos = 0
                      remaining_in_frame = frame_len
                  
                  # Copy chunk
                  chunk_size = min(remaining_in_frame, remaining_in_output)
                  out[pos:pos+chunk_size] = self.current_frame[self.frame_pos:self.frame_pos+chunk_size]
                  pos += chunk_size
                  self.frame_pos += chunk_size
              
              return n
              
          def stop(self):
              """Stop camera capture"""
              self.running = False
              if self.capture_thread is not None:
                  self.capture_thread.join(timeout=2.0)
              return super().stop()
    camera_index: '0'
    fps_target: '60'
    frame_height: '480'
    frame_width: '640'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: TX Spectrum
    name: TX Spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '640'
    fps: '60'
    height: '480'
    type: byte
    width: '640'
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle_0, '0', digital_ofdm_rx_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', video_sdl_sink_0, '0']
- [digital_ofdm_tx_0, '0', blocks_throttle_0, '0']
- [digital_ofdm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
